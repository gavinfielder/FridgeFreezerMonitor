# Keil uVision project Lab6.uvproj, settings and files
target ADC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ADC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab6.c ADC.c Lab6peripherals.c PLL.c uart.c uart.h doorSwitch.c doorSwitch.h friendlywriter.c friendlywriter.h
