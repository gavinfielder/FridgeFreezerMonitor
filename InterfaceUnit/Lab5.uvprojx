# Keil uVision project Lab5.uvprojx, settings and files
target Lab5 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DigitalPiano
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c tm4c123gh6pm.h Lab5.c uart.c uart.h Nokia5110.c Nokia5110.h alarm.c alarm.h friendlywriter.c friendlywriter.h
software components: CMSIS:CORE 5.1.1
